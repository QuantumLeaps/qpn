# IAR project pelican.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3Sx9xx TexasInstruments LM3Sx9xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPN_$\include; cmsis
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: pelican.bin
  ILINK.IlinkOutputFile: pelican.out
  ILINK.IlinkIcfFile: lm3s6965.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  group CMSIS
    cmsis/: startup_ewarm.c system_lm3s.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c
  group Source
    ./: bsp.c bsp.h lm3s_config.h main.c ped.c pelican.c pelican.h rit128x96x4.c rit128x96x4.h
