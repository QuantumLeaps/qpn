# IAR project pelican-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=800
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPN_$\include; cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: pelican-qk.bin
  ILINK.IlinkOutputFile: pelican-qk.out
  ILINK.IlinkIcfFile: lm4f120h5qr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG; PART_LM4F120H5QR; __FPU_PRESENT; TARGET_IS_BLIZZARD_RA1; STACK_SIZE=800
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    cmsis/: startup_ewarm.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
    ../../../../ports/arm-cortex/qk/iar/: qkn_port.s
  group Source
    ./: bsp.c gpio.h main.c pelican.c qpn_port.h rom.h sysctl.h
