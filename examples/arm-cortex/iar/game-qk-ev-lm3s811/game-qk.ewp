# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811; STACK_SIZE=600
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPN_$\include; cmsis
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG; STACK_SIZE=600
  ICCARM.CCOptLevel: 0
  group CMSIS
    cmsis/: startup_ewarm.c system_lm3s.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
    ../../../../ports/arm-cortex/qk/iar/: qkn_port.s
  group Source
    ./: bsp.c display96x16x1.c main.c mine1.c mine2.c missile.c ship.c tunnel.c
