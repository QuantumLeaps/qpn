# IAR project Backup of dpp-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 128
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa50
  ICC430.newCCIncludePaths: .; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\msp430\qk\iar
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.IccLang: 0
  group Application
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
  group QP
    ../../../../../src/qfn/: qepn.c qfn.c
    ../../../../../src/qkn/: qkn.c
