# IAR project pelican-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2013 MSP430F2013
  General.GStackSize2: 90
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ; $_QPN_$\include\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2013.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 64
  group (top)
    ./: bsp.c main.c ped.c pelican.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
