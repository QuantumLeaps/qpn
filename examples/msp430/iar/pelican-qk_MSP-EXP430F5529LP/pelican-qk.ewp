# IAR project pelican-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 80
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ; $_QPN_$\include\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\
  ICC430.CCDefines: NDEBUG
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  group (top)
    ./: bsp.c bsp.h main.c pelican.c pelican.h qpn_port.h
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
