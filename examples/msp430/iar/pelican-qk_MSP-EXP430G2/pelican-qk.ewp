# IAR project pelican-qk.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ; $_QPN_$\include\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 64
  ICC430.CCDefines: NDEBUG
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2013.xcl
  group (top)
    ./: bsp.c bsp.h main.c pelican.c pelican.h
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
