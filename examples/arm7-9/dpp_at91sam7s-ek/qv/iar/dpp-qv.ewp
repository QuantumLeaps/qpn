# IAR project dpp-qv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm7-9\qv\iar; ..\..\..\..\..\3rd_party\at91sam7s-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qv.bin
  ILINK.IlinkOutputFile: dpp-qv.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Application
    ./: bsp.c
    ../../: dpp.h main.c philo.c table.c
  group AT91SAM7S-EK
    ../../../../../3rd_party/at91sam7s-ek/iar/: low_level_init.c startup_at91mc.s
  group QP_ARM
    ../../../../../src/qfn/: qfn.c
    ../../../../../src/qvn/: qvn.c
  group QP_port
    ../../../../../ports/arm7-9/qv/iar/: qfn_port.h qvn_port.s
  group QP_THUMB
    ../../../../../src/qfn/: qepn.c
