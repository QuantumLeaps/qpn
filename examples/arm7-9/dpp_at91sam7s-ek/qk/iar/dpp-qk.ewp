# IAR project dpp-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\arm7-9\qk\iar; ..\..\..\..\..\3rd_party\at91sam7s-ek
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qk.bin
  ILINK.IlinkOutputFile: dpp-qk.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY
  ICCARM.CCOptLevel: 3
  group Application
    ./: bsp.c
    ../../: dpp.h main.c philo.c table.c
  group AT91SAM7S-EK
    ../../../../../3rd_party/at91sam7s-ek/iar/: low_level_init.c startup_at91mc.s
  group QP_ARM
    ../../../../../source/: qfn.c qkn.c
  group QP_port
    ../../../../../ports/arm7-9/qk/iar/: qfn_port.h qkn_port.s
  group QP_THUMB
    ../../../../../source/: qepn.c
