# Keil uVision project pelican.uvproj, settings and files
target pelican-dbg (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: pelican
  AfterMake: fromelf --bin --output .\dbg\pelican.bin .\dbg\pelican.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT
  c include: .;..\..\..\..\include;..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\ports\arm-cm\cmsis
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.c bsp.h pelican.h main.c qpn_port.h startup_tm4c.s tm4c_cmsis.h pelican.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c
target pelican-rel (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: as above
  output: pelican
  AfterMake: fromelf --bin --output .\rel\pelican.bin .\rel\pelican.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk TARGET_IS_BLIZZARD_RA1 __FPU_PRESENT NDEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
