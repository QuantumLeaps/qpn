# Keil uVision project game.uvproj, settings and files
target game-dbg (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: game
  AfterMake: fromelf --bin --output .\dbg\game.bin .\dbg\game.axf
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811
  c include: .;..\..\..\..\include;..\..\..\..\ports\arm-cm\vanilla\arm_keil;..\..\..\..\ports\arm-cm\cmsis
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ./: bsp.c bsp.h display96x16x1.c display96x16x1.h game.h lm3s_config.h main.c qpn_port.h mine1.c mine2.c missile.c ship.c tunnel.c startup_lm3s.s system_lm3s.c
  group Documentation
    ./: readme.txt
  group QP-nano
    ../../../../source/: qepn.c qfn.c
target game-rel (ARM-ADS)
  device: LM3S811 Texas Instruments
  cpu: as above
  output: game
  AfterMake: fromelf --bin --output .\rel\game.bin .\rel\game.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM3S811 NDEBUG
  c include: as above
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
