# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\source; ..\..\..\..\..\ports\arm-cm\qk\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\ek-lm3s811
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: game-qk.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: bsp.c
    ../../: bsp.h game.h main.c mine1.c mine2.c missile.c ship.c tunnel.c
  group ek-lm3s811
    ../../../../../3rd_party/ek-lm3s811/: display96x16x1.c display96x16x1.h LM3S811.h system_LM3S811.c system_LM3S811.h
    ../../../../../3rd_party/ek-lm3s811/iar/: startup_LM3S811.s
  group QP
    ../../../../../source/: qepn.c qfn.c qkn.c
  group QP_port
    ../../../../../ports/arm-cm/qk/iar/: qfn_port.h qk_port.s
