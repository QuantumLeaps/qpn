# Keil uVision project game-qk.uvprojx, settings and files
target game-dbg (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: game-qk
  AfterMake: fromelf --bin --output .\dbg\game-qk.bin .\dbg\game-qk.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\source;..\..\..\..\..\ports\arm-cm\qk\arm;..\..\..\..\..\3rd_party\CMSIS\Include\;..\..\..\..\..\3rd_party\ek-lm3s811
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c
    ../../: bsp.h game.h main.c mine1.c mine2.c missile.c ship.c tunnel.c
  group ek-lm3s811
    ../../../../../3rd_party/ek-lm3s811/: display96x16x1.c display96x16x1.h LM3S811.h system_LM3S811.c system_LM3S811.h
    ../../../../../3rd_party/ek-lm3s811/arm/: startup_LM3S811.s
  group QP
    ../../../../../source/: qepn.c qfn.c qkn.c
  group QP_port
    ../../../../../ports/arm-cm/qk/arm/: qk_port.s qfn_port.h
target game-rel (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: game-qk
  AfterMake: fromelf --bin --output .\rel\game-qk.bin .\rel\game-qk.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
