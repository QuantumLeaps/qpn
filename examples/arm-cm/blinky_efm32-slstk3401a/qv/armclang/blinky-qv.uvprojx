# Keil uVision project blinky-qv.uvprojx, settings and files
target blinky-dbg (6130001::V6.13.1::.\ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky-qv
  BeforeMake: cmd /c "del .\dbg\qstamp.o"
  AfterMake: fromelf --bin --output .\dbg\blinky-qv.bin .\dbg\blinky-qv.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\armclang;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\efm32pg1b
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Applicatioin
    ../: bsp.c
    ../../: blinky.c main.c blinky.h
    ../../../../../include/: qstamp.c
  group efm32pg1b
    ../../../../../3rd_party/efm32pg1b/: em_cmu.c em_emu.c em_gpio.c em_int.c em_rtcc.c em_system.c system_efm32pg1b.c
    ../../../../../3rd_party/efm32pg1b/arm/: startup_efm32pg1b.s
  group QP
    ../../../../../src/qfn/: qepn.c qfn.c
    ../../../../../src/qvn/: qvn.c
  group QP_port
    ../../../../../ports/arm-cm/qv/armclang/: qfn_port.h qvn_port.c
target blinky-rel (6130001::V6.13.1::.\ARMCLANG)
  device: EFM32PG1B200F256GM48 Silicon Labs
  pack: SiliconLabs.EFM32PG1B_DFP.5.5.0
  cpu: as above
  output: blinky-qv
  BeforeMake: cmd /c "del .\rel\qstamp.o"
  AfterMake: fromelf --bin --output .\rel\blinky-qv.bin .\rel\blinky-qv.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG EFM32PG1B200F256GM48=1 __FPU_PRESENT
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
