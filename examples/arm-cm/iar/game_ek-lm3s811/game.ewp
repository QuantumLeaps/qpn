# IAR project game.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S811
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPN_$\include; $_QPN_$\ports\arm-cm\vanilla\iar; $_QPN_$\ports\arm-cm\cmsis
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game.bin
  ILINK.IlinkOutputFile: game.out
  ILINK.IlinkIcfFile: game.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG
  ICCARM.CCOptStrategy: 1
  group QP-nano
    ../../../../source/: qepn.c qfn.c
  group Source
    ./: bsp.c bsp.h display96x16x1.c display96x16x1.h game.h lm3s_config.h main.c mine1.c mine2.c missile.c qpn_port.h ship.c startup_lm3s.c system_lm3s.c tunnel.c
