# IAR project dpp-qv.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\include; ..\..\..\..\..\ports\arm-cm\qv\iar; ..\..\..\..\..\3rd_party\CMSIS\Include; ..\..\..\..\..\3rd_party\mbed-lpc1768
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-qv.bin
  ILINK.IlinkOutputFile: dpp-qv.out
  ILINK.IlinkIcfFile: dpp-qv.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
  group mbed-lpc1768
    ../../../../../3rd_party/mbed-lpc1768/: LPC17xx.h system_LPC17xx.c system_LPC17xx.h
    ../../../../../3rd_party/mbed-lpc1768/iar/: startup_LPC17xx.s
  group QP
    ../../../../../src/qfn/: qepn.c qfn.c
    ../../../../../src/qvn/: qvn.c
  group QP_port
    ../../../../../ports/arm-cm/qv/iar/: qfn_port.h qvn_port.c
