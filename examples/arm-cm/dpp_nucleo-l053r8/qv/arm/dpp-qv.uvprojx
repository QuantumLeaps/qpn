# Keil uVision project dpp-qv.uvprojx, settings and files
target dpp-dbg (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: dpp-qv
  AfterMake: fromelf --bin --output .\dbg\dpp-qv.bin .\dbg\dpp-qv.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..;..\..\..\..\..\include;..\..\..\..\..\ports\arm-cm\qv\arm;..\..\..\..\..\3rd_party\CMSIS\Include;..\..\..\..\..\3rd_party\nucleo-l053r8
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
  group Source Code
    ../: bsp.c
    ../../: bsp.h dpp.h main.c philo.c table.c
  group nucleo-l053r8
    ../../../../../3rd_party/nucleo-l053r8/: stm32l0xx.h stm32l053xx.h system_stm32l0xx.c system_stm32l0xx.h
    ../../../../../3rd_party/nucleo-l053r8/arm/: startup_stm32l053xx.s
  group QP
    ../../../../../src/qfn/: qepn.c qfn.c
    ../../../../../src/qvn/: qvn.c
  group QP_port
    ../../../../../ports/arm-cm/qv/arm/: qvn_port.c
target dpp-rel (ARM-ADS)
  device: STM32L053R8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: dpp-qv
  AfterMake: fromelf --bin --output .\rel\dpp-qv.bin .\rel\dpp-qv.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG
  c include: as above
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --entry Reset_Handler
