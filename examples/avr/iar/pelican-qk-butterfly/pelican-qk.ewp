# IAR project pelican-qk.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0
  General.SCCStackSize: 0x40
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $PROJ_DIR$; ..\..\..\..\include
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm169.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  ICCAVR.CCDefines: NDEBUG
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: bsp.c main.c ped.c pelican.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
