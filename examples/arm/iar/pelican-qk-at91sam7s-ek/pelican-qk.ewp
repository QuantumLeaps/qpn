# IAR project pelican-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; $_QPN_$\include; $TOOLKIT_DIR$\inc\atmel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: pelican-qk.bin
  ILINK.IlinkOutputFile: pelican-qk.out
  ILINK.IlinkIcfFile: at91SAM7S64.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG
  group Active Objects
    ./: pelican.c pelican.h
  group BSP
    ./: at91mc_cstartup.s bsp.c bsp.h main.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
    ../../../../ports/arm/qk/iar/: qkn_port.s
    ./: qpn_port.h
